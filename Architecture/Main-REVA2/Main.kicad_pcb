# Repository BaguettePNG/PTrans-2025-2026

## KiCad design Architecture/Main-REVA2/Main.kicad_pcb

Parts:
H1, H2, H3, H4: MountingHole; MountingHole_2.2mm_M2_ISO7380
U5: Logo_20_20

Notes on the sheet:
Mechanic
Logo

Parts:
C2, C6, C19: 100nF; C_Disc_D5.0mm_W2.5mm_P5.00mm
C3, C16, C17: 100nF; C_Disc_D5.0mm_W2.5mm_P5.00mm; not fitted
J3: Conn_01x03; PinHeader_1x03_P2.54mm_Vertical
J4: Conn_01x04; PinHeader_1x04_P2.54mm_Vertical; not fitted
J6: Conn_01x04; PinHeader_1x04_P2.54mm_Vertical
J7, J8: Conn_01x06; PinHeader_1x06_P2.54mm_Vertical
J11, J12: 110990030; Grove; PARTREV A; not fitted
Q1: IRF540N; TO-220-3_Vertical
R3: 1k; R_Axial_DIN0207_L6.3mm_D2.5mm_P10.16mm_Horizontal
R6: 10k; R_Axial_DIN0207_L6.3mm_D2.5mm_P10.16mm_Horizontal

Connections:
+5V: C2.1, C3.1, C6.1, C16.1, C17.1, C19.1, J3.1, J4.1, J6.1, J7.3, J8.1, J11.2, J12.2; also elsewhere on the board
/Cam/SCL: J8.3, J11.4, J12.4; also elsewhere on the board
/Cam/SDA: J8.4, J11.3, J12.3; also elsewhere on the board
/Sensors/DATA_DHT22: J4.2; also elsewhere on the board
/Sensors/ENA_GPS: R3.1; also elsewhere on the board
/Sensors/PIR_MOUV: J3.2, R6.1; also elsewhere on the board
/Sensors/RX0: J6.3, J7.5; also elsewhere on the board
/Sensors/TX0: J6.2, J7.4; also elsewhere on the board
GND: C3.2, C6.2, C16.2, C17.2, C19.2, J3.3, J4.4, J6.4, J7.1, J8.2, J11.1, J12.1, Q1.2 (D), R6.2; also elsewhere on the board
unnamed: Q1.1 (G), R3.2
unnamed: C2.2, Q1.3 (S)

Notes on the sheet:
RX_GPS
I2C_Sensor_Groove
PA1010D
VCC
GND
VCC_GPS
PIR - Mouv Detector
DATA
TX_GPS
BME680
BN220
PPS
GPS Sensor ( RX/TX0 )
WAKE
BME680 - Temp;Hum;Press;Qual
DHT22 Sensor

Parts:
C4: 100nF; C_Disc_D5.0mm_W2.5mm_P5.00mm
J5: Conn_01x06
U2: SD_CARD

Connections:
+5V: C4.1, J5.5; also elsewhere on the board
/Stockage/CS: J5.1; also elsewhere on the board
/Stockage/MISO: J5.4; also elsewhere on the board
/Stockage/MOSI: J5.3; also elsewhere on the board
/Stockage/SCK: J5.2; also elsewhere on the board
GND: C4.2, J5.6; also elsewhere on the board

Notes on the sheet:
SD Card ( __ GO )
Card Adapter

Parts:
C18: 100uF; C_Radial_D10.0mm_H16.0mm_P5.00mm
C20: 100nF; C_Disc_D5.0mm_W2.5mm_P5.00mm
D3: D; D_DO-35_SOD27_P7.62mm_Horizontal
R18, R19: 4.7k; R_Axial_DIN0207_L6.3mm_D2.5mm_P10.16mm_Horizontal
U4: ESP32-S3-DEVKITC-1-N8R8

Connections:
/Cam/+VCC_Alim: D3.2 (A), R18.2, R19.2; also elsewhere on the board
/Cam/D0: U4.J1_14 (GPIO46); also elsewhere on the board
/Cam/D1: U4.J1_13 (GPIO3); also elsewhere on the board
/Cam/D2: U4.J1_9 (GPIO16); also elsewhere on the board
/Cam/D3: U4.J1_8 (GPIO15); also elsewhere on the board
/Cam/D4: U4.J1_7 (GPIO7); also elsewhere on the board
/Cam/D5: U4.J1_6 (GPIO6); also elsewhere on the board
/Cam/D6: U4.J1_5 (GPIO5); also elsewhere on the board
/Cam/D7: U4.J1_4 (GPIO4); also elsewhere on the board
/Cam/DCLK: U4.J1_20 (GPIO14); also elsewhere on the board
/Cam/HREF: U4.J3_9 (MTCK/GPIO39); also elsewhere on the board
/Cam/LED_IR: U4.J3_16 (GPIO48); also elsewhere on the board
/Cam/SCL: R18.1, U4.J1_15 (GPIO9); also elsewhere on the board
/Cam/SDA: R19.1, U4.J1_12 (GPIO8); also elsewhere on the board
/Cam/VREF: U4.J3_8 (MTDO/GPIO40); also elsewhere on the board
/Power/PWR_U/D: U4.J3_5 (GPIO2); also elsewhere on the board
/Power/VOLTAGE_BAT: U4.J3_17 (GPIO47); also elsewhere on the board
/Sensors/DATA_DHT22: U4.J3_10 (GPIO38); also elsewhere on the board
/Sensors/DEBUG: U4.J3_15 (GPIO45); also elsewhere on the board
/Sensors/ENA_GPS: U4.J3_18 (GPIO21); also elsewhere on the board
/Sensors/PIR_MOUV: U4.J3_4 (GPIO1); also elsewhere on the board
/Sensors/RX0: U4.J1_11 (GPIO18); also elsewhere on the board
/Sensors/TX0: U4.J1_10 (GPIO17); also elsewhere on the board
/Stockage/CS: U4.J1_16 (GPIO10); also elsewhere on the board
/Stockage/MISO: U4.J1_18 (GPIO12); also elsewhere on the board
/Stockage/MOSI: U4.J1_17 (GPIO11); also elsewhere on the board
/Stockage/SCK: U4.J1_19 (GPIO13); also elsewhere on the board
/Transmission/RX: U4.J3_7 (MTDI/GPIO41); also elsewhere on the board
/Transmission/TX: U4.J3_6 (MTMS/GPIO42); also elsewhere on the board
/uc/+3.3V: U4.J1_1 (3V3), U4.J1_2 (3V3.)
GND: C18.2, C20.2, U4.J1_22 (GND3), U4.J3_1 (GND), U4.J3_21 (GND1), U4.J3_22 (GND2); also elsewhere on the board
unnamed: C18.1, C20.1, D3.1 (K), U4.J1_21 (5V0)

Parts:
C8, C14: 100µF; C_Radial_D10.0mm_H16.0mm_P5.00mm
C9, C11, C13, C15: 100nF; C_Disc_D5.0mm_W2.5mm_P5.00mm
C10: 1µF; C_Radial_D10.0mm_H16.0mm_P5.00mm
C12: 470µF; C_Radial_D10.0mm_H16.0mm_P5.00mm
D1, D2: D; D_DO-35_SOD27_P7.62mm_Horizontal
J10: IN; PinHeader_1x02_P2.54mm_Vertical; not fitted
J14: OUT_5V_ALI; PinHeader_1x02_P2.54mm_Vertical; not fitted
J16: OUT_5V_PWR; PinHeader_1x02_P2.54mm_Vertical; not fitted
J17: Barrel_Jack_Switch_Pin3Ring; BarrelJack_Horizontal
JP1: Jumper_2_Bridged; PinHeader_1x02_P2.54mm_Vertical
L1: 22µH; R_Axial_DIN0207_L6.3mm_D2.5mm_P10.16mm_Horizontal
Q2: PN2222A; TO-92_Inline
Q3: IRF9540N; TO-220-3_Vertical
R1, R9: 100k; R_Axial_DIN0207_L6.3mm_D2.5mm_P10.16mm_Horizontal
R2: 25k; R_Axial_DIN0207_L6.3mm_D2.5mm_P10.16mm_Horizontal
R4: 52.3k; R_Axial_DIN0207_L6.3mm_D2.5mm_P10.16mm_Horizontal
R7, R10, R11: 10k; R_Axial_DIN0207_L6.3mm_D2.5mm_P10.16mm_Horizontal
R8: 1k; R_Axial_DIN0207_L6.3mm_D2.5mm_P10.16mm_Horizontal
U3: MCP16311x-xMS; MSOP-8_3x3mm_P0.65mm

Connections:
+5V: C14.1, C15.1, J16.1, Q3.2 (D), R11.1; also elsewhere on the board
+12V: C8.1, C9.1, D1.1 (K), D2.1 (K), R1.1, U3.3 (EN), U3.4 (V_{IN}); also elsewhere on the board
/Cam/+VCC_Alim: C11.2, C12.1, C13.1, J14.1, JP1.1 (A), L1.2, R4.1; also elsewhere on the board
/Cam/PWDN: Q3.1 (G), R9.2, R10.1; also elsewhere on the board
/Power/PWR_U/D: R8.1; also elsewhere on the board
/Power/VOLTAGE_BAT: R1.2, R2.1; also elsewhere on the board
GND: C8.2, C9.2, C10.2, C12.2, C13.2, C14.2, C15.2, J10.1, J14.2, J16.2, J17.2, J17.3, Q2.1 (E), R2.2, R7.2, R11.2, U3.5 (GND), U3.8 (GND); also elsewhere on the board
unnamed: D1.2 (A), J17.1
unnamed: D2.2 (A), J10.2
unnamed: JP1.2 (B), Q3.3 (S), R9.1
unnamed: Q2.2 (B), R8.2
unnamed: Q2.3 (C), R10.2
unnamed: C11.1, U3.7 (BOOST)
unnamed: L1.1, U3.6 (SW)
unnamed: C10.1, U3.2 (V_{CC})
unnamed: R4.2, R7.1, U3.1 (Vfb)

Notes on the sheet:
https://www.microchip.com/en-us/parametric-search/418?filters=JTdCJTIyYWN0aXZlU2xpZGVyRmlsdGVycyUyMiUzQSU1QiU1QiUyMlZJTiUyME1pbiUyMFYlMjAodm9sdCklMjIlMkMlNUI0LjIlMkMyLjIlNUQlNUQlNUQlMkMlMjJjYXRlZ29yeWRyb3Bkb3duJTIyJTNBJTVCJTIyUG93ZXIlMjBNYW5hZ2VtZW50JTIyJTJDJTIyREMtREMlMjBCb29zdCUyMChTdGVwLVVwKSUyM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
MAUVAISE EMPREINTE INDUCTOR
Mesure Battery Voltage

Parts:
C1, C7: 100nF; C_Disc_D5.0mm_W2.5mm_P5.00mm
J2: Conn_01x02; PinHeader_1x02_P2.54mm_Vertical
J9: Conn_02x09_Odd_Even; OV2640
Q4: IRF540N; TO-220-3_Horizontal_TabDown
R5: 1k; R_Axial_DIN0207_L6.3mm_D2.5mm_P10.16mm_Horizontal

Connections:
+12V: C7.1, J2.1; also elsewhere on the board
/Cam/+VCC_Alim: C1.1, J9.1, J9.7; also elsewhere on the board
/Cam/D0: J9.8; also elsewhere on the board
/Cam/D1: J9.9; also elsewhere on the board
/Cam/D2: J9.10; also elsewhere on the board
/Cam/D3: J9.11; also elsewhere on the board
/Cam/D4: J9.12; also elsewhere on the board
/Cam/D5: J9.13; also elsewhere on the board
/Cam/D6: J9.14; also elsewhere on the board
/Cam/D7: J9.15; also elsewhere on the board
/Cam/DCLK: J9.16; also elsewhere on the board
/Cam/HREF: J9.5; also elsewhere on the board
/Cam/LED_IR: R5.1; also elsewhere on the board
/Cam/PWDN: J9.18; also elsewhere on the board
/Cam/SCL: J9.4; also elsewhere on the board
/Cam/SDA: J9.6; also elsewhere on the board
/Cam/VREF: J9.3; also elsewhere on the board
GND: C1.2, J9.2, Q4.3 (S); also elsewhere on the board
unnamed: C7.2, J2.2, Q4.2 (D)
unnamed: Q4.1 (G), R5.2

Notes on the sheet:
LED IR
https://fr.rs-online.com/web/p/borniers-enfichables/0446319
CAMERA
https://fr.rs-online.com/web/p/borniers-enfichables/0446488

Parts:
C5: 100nF; Capa disc radial 5.08mm
J1: Conn_01x04; PinHeader_1x04_P2.54mm_Vertical
U1: (no value)

Connections:
+5V: C5.2, J1.4; also elsewhere on the board
/Transmission/RX: J1.1; also elsewhere on the board
/Transmission/TX: J1.2; also elsewhere on the board
GND: C5.1, J1.3; also elsewhere on the board

Notes on the sheet:
SIM Card ( ___ )
GND
4G Module ( RX/TX )
RX_MODULE_4G
VCC_GPS
TX_MODULE_4G

Board: 2 copper layers, 100.0 x 100.0 mm, 68 parts (11 on the bottom side), 51 nets.

Other parts of the board:
D4: LED; LED_D5.0mm
Q5: PN2222A; TO-92_Inline
R12: 10k; R_Axial_DIN0207_L6.3mm_D2.5mm_P10.16mm_Horizontal
R13: 1k; R_Axial_DIN0207_L6.3mm_D2.5mm_P10.16mm_Horizontal

Their connections:
+5V: R12.1; also elsewhere on the board
/Sensors/DEBUG: R13.1; also elsewhere on the board
GND: Q5.1 (E); also elsewhere on the board
unnamed: D4.2 (A), R12.2
unnamed: D4.1 (K), Q5.3 (C)
unnamed: Q5.2 (B), R13.2

## Commit log

2025-10-26 Corection
2025-11-22 Gestion_1
2025-11-22 Archi_1
2025-11-28 Archi_2
2025-11-30 CodeGPS+RTC
2025-12-05 Automation_Start
2025-12-11 Code_CAM
2025-12-12 11_12_2025
2025-12-14 Update_BAD
2025-12-30 Update Schematic
2025-12-31 Update Code For OV2640
2025-12-31 Power Sector Update
2026-01-06 Code_Camera_OK
2026-01-07 Update_07_01_2026
2026-01-08 CodeFinalProto_plus_majarchitecture
2026-01-13 Update_She
2026-01-14 Code_Opti_Conso_Protoype
2026-01-16 Update_Code
2026-01-17 Nouvelle_ESP
2026-01-18 Update_PSRAM
2026-01-22 Update_Schematic
2026-01-23 Update_Sche
2026-01-25 Update_Schematic_PCB
2026-01-28 Update_28_01_2025
2026-01-28 Update_PCB
2026-01-30 Update_30_01_2026
2026-02-01 update_01_02_2026
2026-02-08 Update_6_02_2026
2026-02-10 Update_10_02_2026
2026-03-31 Update_Mars_Recovers
2026-03-31 Update_Mars_31_ALL
2026-04-08 Update_08_04_206_26_PC
2026-04-09 Update_09_04_2026_DELL
2026-04-09 Update_09_04_2026_PC
2026-04-10 Update_10_04_2026_PC
2026-04-10 Update_Correction_Orthographe_DELL
